# Keil uVision project AngleDisplay.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STC89C52 STC
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODA2
  output: AngleDisplay +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT9: RAM 0x0 size 0x100
  group Source Group 1
    ./: main.c
